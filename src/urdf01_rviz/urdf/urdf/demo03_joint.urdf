Commit message: change demo03_joint

File: src/urdf01_rviz/urdf/urdf/demo03_joint.urdf (robot description, URDF)
Before this commit: robot demo03_joint, 2 links, 1 joints
Joints:
- joint clild2parent: origin xyz=0.2 0.0 0.15 rpy=0.0 0.0 0.0 -> xyz=0.2 0.0 0.05 rpy=0.0 0.0 0.0
